# Keil uVision project BootLoader_F103C8T6.uvprojx, settings and files
target Boot_F103C8T6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BootLoader_F103C8T6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB
  c include: ..\..\Source\Integration\Core;..\..\Source\Integration\Device;..\..\Source\Integration\Startup;..\..\Source\Integration\UserCommon;..\..\Source\BasicSoftware\Hal_Driver\Inc;..\..\Source\BasicSoftware\Hal_Driver\Inc\Legacy;..\..\Source\BasicSoftware\ConfigCode\Inc;..\..\Source\BasicSoftware\OS;..\..\Source\BasicSoftware\Interface;..\..\Source\Application
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Basic/HalDriver
    ../../Source/BasicSoftware/Hal_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Basic/Integration
    ../../Source/Integration/Startup/: startup_stm32f103xb.s
    ../../Source/Integration/UserCommon/: UserPublic.c
  group Basic/Config
    ../../Source/BasicSoftware/ConfigCode/Src/: dma.c gpio.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c tim.c usart.c stm32f1xx_hal_timebase_tim.c
  group OS
    ../../Source/BasicSoftware/OS/: OsTask.c OsTask_Cfg.c OsTimer.c
  group BSW/UserIf
    ../../Source/BasicSoftware/Interface/: Dio_UserIf.c Flash_UserIf.c Uart_UserIf.c
  group ASW
    ../../Source/Application/: App_Boot.c
